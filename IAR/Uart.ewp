# IAR project Uart.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: DEBUG; STM8L15X_MD
  ICCSTM8.CCIncludePath2: code\App; code\Drivers\stm8l152
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Uart.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    code/App/: debug.c debug.h gpio.c gpio.h i2c.c i2c.h main.c main.h rcc.c rtc.c uart.c uart.h
  group Drivers
    code/Drivers/stm8l152/: eeprom.c stm8l15x_flash.c
